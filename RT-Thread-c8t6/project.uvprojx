# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: RT_src\components\libc\compilers\common\extension;Library\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;Library\HAL_Drivers;.;RT_src\components\libc\posix\ipc;applications;RT_src\libcpu\arm\common;board\CubeMX_Config\Inc;RT_src\components\drivers\include;RT_src\components\finsh;RT_src\libcpu\arm\cortex-m3;Library\HAL_Drivers\config;RT_src\include;RT_src\components\libc\posix\io\stdio;Library\HAL_Drivers\CMSIS\Include;Library\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;RT_src\components\libc\posix\io\poll;RT_src\components\drivers\include;RT_src\components\libc\compilers\common\include;RT_src\components\drivers\include;RT_src\components\libc\compilers\common\extension\fcntl\octal;board
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    RT_src/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    RT_src/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    RT_src/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    RT_src/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    RT_src/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    RT_src/components/drivers/misc/: pin.c
    RT_src/components/drivers/serial/: serial.c
  group Drivers
    Library/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    Library/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    RT_src/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    RT_src/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    Library/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    Library/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
